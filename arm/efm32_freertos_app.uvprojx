# Keil uVision project efm32_freertos_app.uvprojx, settings and files
target efm32_freertos_app (ARM-ADS)
  device: EFM32GG230F512 Silicon Labs
  pack: Keil.EFM32GGxxx_DFP.2.4.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: efm32_freertos_app +hex
  AfterMake: fromelf.exe --bin --output obj\efm32_freertos_app.bin obj\efm32_freertos_app.axf
  AfterMake: ..\script_A\_cp_all_hex.bat
  c flags: Optim=4 OneElfS=1
  c define: BSP_A  EFM32GG230F512  DEBUG_EFM
  c misc: --c99
  c include: ..\common\CMSIS\Include;..\common\DEVICE\efm32gg\Include;..\common\FreeRTOS\efm32gg\Source\include;..\common\FreeRTOS\efm32gg\Source\portable\RVDS\ARM_CM3;..\src;..\src\bsp\common;..\src\bsp\common\emdrv\common\inc;..\src\bsp\common\emdrv\config;..\src\bsp\common\emdrv\dmadrv\inc;..\src\bsp\common\emdrv\gpiointerrupt\inc;..\src\bsp\common\emdrv\sleep\inc;..\src\bsp\common\emdrv\spidrv\inc;..\src\bsp\common\emdrv\uartdrv\inc;..\src\bsp\common\emdrv\ustimer\inc;..\src\bsp\common\emlib\inc;..\src\bsp\system\misc;..\src\bsp\uart_device;..\src\bsp\uart_device\log;..\src\bsp;..\src\framework\components\app_schedule;..\src\framework\components\app_timer;..\src\framework\components\delay;..\src\framework\components\platform;..\src\app;..\src\app\app_manager;..\src\app\app_manager\task\sys;..\src\app\hal_manager;..\src\app\thread_manager;..\src\app\thread_manager\thread_monitor;..\src\app\thread_manager\power_manager;..\bootloader\util;..\src\public_libs\common_libs;..\src\public_libs\common_libs\app_error;..\src\public_libs\common_libs\calendar;..\src\public_libs\common_libs\common_string;..\src\public_libs\common_libs\crc16;..\src\public_libs\common_libs\datetime;..\src\public_libs\common_libs\list;..\src\public_libs\common_libs\poll_buffer;..\src\public_libs\common_libs\softwdt;..\src\public_libs\common_libs\wait_event
  asm include: ..\DEVICE\efm32gg\Include
  memory RVCT4: ROM 0x4100 size 0x39f00
  memory RVCT9: RAM 0x20000000 size 0x20000
  group common
    ../common/DEVICE/efm32gg/: system_efm32gg.c startup_arm-efm32gg.s
    ../common/FreeRTOS/efm32gg/Source/: croutine.c event_groups.c list.c queue.c readme.txt tasks.c timers.c
    ../common/FreeRTOS/efm32gg/Source/portable/RVDS/ARM_CM3/: port.c
    ../common/FreeRTOS/efm32gg/Source/portable/MemMang/: heap_4.c
  group src
    ../src/: main.c
  group app
    ../src/app/thread_manager/: thread_manager.c
    ../src/app/thread_manager/power_manager/: low_power_tick_management.c
    ../src/app/thread_manager/thread_monitor/: trace.c
    ../src/app/app_manager/task/sys/: sys_task.c
    ../src/app/hal_manager/: hal_manager.c
    ../src/app/app_manager/: app_manager.c
  group framework
    ../src/framework/components/app_schedule/: app_schedule.c
    ../src/framework/components/app_timer/: app_timer.c app_timer_drv.c app_timer_hal_burtc.c app_timer_hal_rtc.c app_timer_wall_clock.c app_timer_hal_letimer.c
    ../src/framework/components/delay/: delay.c nop_delay.c
    ../src/framework/components/platform/: platform.c
  group bsp
    ../src/bsp/system/misc/: wdt.c wall_clock_timer.c inner_rtc_action.c
    ../src/bsp/uart_device/log/: log.c log_cmd.c log_uart.c
    ../src/bsp/uart_device/: uart_driver.c
  group bsp_common
    ../src/bsp/common/: dmactrl.c i2cspm.c
    ../src/bsp/common/emlib/src/: em_acmp.c em_adc.c em_aes.c em_assert.c em_burtc.c em_cmu.c em_cryotimer.c em_crypto.c em_dac.c em_dbg.c em_dma.c em_ebi.c em_emu.c em_gpcrc.c em_gpio.c em_i2c.c em_idac.c em_int.c em_lcd.c em_ldma.c em_lesense.c em_letimer.c em_leuart.c em_mpu.c em_msc.c em_opamp.c em_pcnt.c em_prs.c em_rmu.c em_rtc.c em_rtcc.c em_system.c em_timer.c em_usart.c em_vcmp.c em_wdog.c
    ../src/bsp/common/emdrv/dmadrv/src/: dmadrv.c
    ../src/bsp/common/emdrv/gpiointerrupt/src/: gpiointerrupt.c
    ../src/bsp/common/emdrv/sleep/src/: sleep.c
    ../src/bsp/common/emdrv/spidrv/src/: spidrv.c
    ../src/bsp/common/emdrv/uartdrv/src/: uartdrv.c
  group common_libs
    ../src/public_libs/common_libs/calendar/: calendar.c
    ../src/public_libs/common_libs/app_error/: app_error.c
    ../src/public_libs/common_libs/common_string/: common_string.c
    ../src/public_libs/common_libs/crc16/: crc16.c
    ../src/public_libs/common_libs/datetime/: datetime.c
    ../src/public_libs/common_libs/list/: list.c
    ../src/public_libs/common_libs/poll_buffer/: poll_buffer.c
    ../src/public_libs/common_libs/softwdt/: softwdt.c
    ../src/public_libs/common_libs/wait_event/: event.c
    ../src/public_libs/common_libs/: common.c
