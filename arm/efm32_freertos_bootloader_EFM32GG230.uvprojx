# Keil uVision project efm32_freertos_bootloader_EFM32GG230.uvprojx, settings and files
target bootloader_EFM32GG230 (ARM-ADS)
  device: EFM32GG230F512 Silicon Labs
  pack: Keil.EFM32GGxxx_DFP.2.4.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: bootloader_EFM32GG230 +hex
  AfterMake: fromelf.exe --bin --output obj1\bootloader_EFM32GG230.bin obj1\bootloader_EFM32GG230.axf
  c flags: Optim=4 OneElfS=1
  c define: BSP_A EFM32GG230F512 DEBUG_EFM USE_BOOTLOADER
  c misc: --c99
  c include: ..\common\CMSIS\Include;..\common\DEVICE\efm32gg\Include;..\common\FreeRTOS\efm32gg\Source\include;..\common\FreeRTOS\efm32gg\Source\portable\RVDS\ARM_CM3;..\bootloader;..\bootloader\util;..\src\bsp\uart_device\log;..\src\bsp\system\misc;..\src\bsp\common\emlib\inc;..\src\public_libs\common_libs\app_error;..\src\public_libs\common_libs\crc16;..\src\public_libs\common_libs\common_string;..\src\public_libs\common_libs;..\src\framework\components\platform;..\src;..\src\bsp\uart_device;..\src\bsp\fs\storage;..\src\bsp;..\src\bsp\common\emdrv\uartdrv\inc;..\src\bsp\common\emdrv\config;..\src\bsp\common\emdrv\common\inc;..\src\bsp\common\emdrv\dmadrv\inc;..\src\app;..\src\framework\components\delay;..\src\public_libs\common_libs\calendar
  asm include: ..\DEVICE\efm32gg\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group common
    ../common/DEVICE/efm32gg/: startup_arm-efm32gg.s system_efm32gg.c
  group src
    ../bootloader/: boot_hal_manager.c boot_main.c
    ../src/public_libs/common_libs/crc16/: crc16.c
  group framework
    ../src/public_libs/common_libs/app_error/: app_error.c
  group util
    ../bootloader/util/: aes.c aes_keys.c boot.c crc.c debuglock.c flash.c uart.c verify.c xmodem.c boot_bootloader.c
  group bsp
    ../src/bsp/uart_device/log/: log.c
    ../src/bsp/system/misc/: wdt.c
  group bsp_common
    ../src/bsp/common/emlib/src/: em_acmp.c em_adc.c em_aes.c em_assert.c em_burtc.c em_cmu.c em_cryotimer.c em_crypto.c em_dac.c em_dbg.c em_dma.c em_ebi.c em_emu.c em_gpcrc.c em_gpio.c em_i2c.c em_idac.c em_int.c em_lcd.c em_ldma.c em_lesense.c em_letimer.c em_leuart.c em_mpu.c em_msc.c em_opamp.c em_pcnt.c em_prs.c em_rmu.c em_rtc.c em_rtcc.c em_system.c em_timer.c em_usart.c em_vcmp.c em_wdog.c
software components: CMSIS:CORE 4.3.0
